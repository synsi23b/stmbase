# IAR project iar_project_template.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 512
  General.GenHeapSize: 0x0
  ICCSTM8.CCDefines: STM8S103; DEBUG
  ICCSTM8.CCDiagSuppress: Pe170
  ICCSTM8.CCIncludePath2: $WS_DIR$\stmbase\synos8; $WS_DIR$\stmbase\synhal8
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: {project}.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenStackSize: 200
  ICCSTM8.CCDefines: NDEBUG; STM8S103
  ILINK.IlinkOutputFile: {project}.out
  group src
    src/: main.cpp synhal_cfg.h
  group synhal
    stmbase/synhal8/: synhal.cpp synhal.h
  group synos
    stmbase/synos8/: synos.cpp synos.h synos_asm.s
